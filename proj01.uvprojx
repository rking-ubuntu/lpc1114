# Keil uVision project proj01.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: LPC1114FHI33/302 NXP
  pack: Keil.LPC1100_DFP.1.4.0
  cpu: IROM(0x00000000,0x8000) IRAM(0x10000000,0x2000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: proj01 +hex
  c flags: Optim=1
  c include: E:\keil514\ARM\Pack\ARM\CMSIS\4.2.0\CMSIS/Include;..\proj01
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: proj01.sct
  group Source Group 1
    ./: beep.c blinky.c digitSeg.c key.c led.c system_init.c timer.c startup_LPC11xx.s i2c9664.c
